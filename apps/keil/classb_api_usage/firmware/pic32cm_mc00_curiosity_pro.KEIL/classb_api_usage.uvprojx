# Keil uVision project classb_api_usage.uvprojx, settings and files
target pic32cm_mc00_curiosity_pro (6160000::V6.16::ARMCLANG)
  device: PIC32CM1216MC00048 Microchip
  pack: Microchip.PIC32CM-MC_DFP.1.2.52
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) IROM2(0x00400000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: pic32cm_mc00_curiosity_pro
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\src\config\pic32cm_mc00_curiosity_pro;..\src\packs\PIC32CM1216MC00048_DFP;..\src\packs\CMSIS\CMSIS\Core\Include;..\src\packs\CMSIS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\src\config\pic32cm_mc00_curiosity_pro\pic32cm_mc00_curiosity_pro.sct
  group Harmony3
    ../src/config/pic32cm_mc00_curiosity_pro/peripheral/nvmctrl/: plib_nvmctrl.h plib_nvmctrl.c
    ../src/config/pic32cm_mc00_curiosity_pro/peripheral/evsys/: plib_evsys.h plib_evsys.c
    ../src/config/pic32cm_mc00_curiosity_pro/peripheral/sercom/usart/: plib_sercom0_usart.h plib_sercom_usart_common.h plib_sercom0_usart.c
    ../src/config/pic32cm_mc00_curiosity_pro/: device.h device_cache.h toolchain_specifics.h definitions.h interrupts.h device_vectors.h initialization.c interrupts.c exceptions.c startup_keil.c
    ../src/packs/PIC32CM1216MC00048_DFP/component/: ac.h adc.h ccl.h dac.h divas.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h hmatrixb.h mclk.h mtb.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pdec.h pm.h port.h rstc.h rtc.h sdadc.h sercom.h supc.h tc.h tcc.h tsens.h wdt.h
    ../src/packs/PIC32CM1216MC00048_DFP/instance/: ac.h adc0.h adc1.h ccl.h dac.h divas.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h hmatrixhs.h mclk.h mtb.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pdec.h pm.h port.h rstc.h rtc.h sdadc.h sercom0.h sercom1.h sercom2.h sercom3.h supc.h tc0.h tc1.h tc2.h tc3.h tc4.h tcc0.h tcc1.h tcc2.h tsens.h wdt.h
    ../src/packs/PIC32CM1216MC00048_DFP/: pic32cm1216mc00048.h
    ../src/packs/PIC32CM1216MC00048_DFP/pio/: pic32cm1216mc00048.h
    ../src/config/pic32cm_mc00_curiosity_pro/peripheral/port/: plib_port.h plib_port.c
    ../src/config/pic32cm_mc00_curiosity_pro/peripheral/clock/: plib_clock.h plib_clock.c
    ../src/config/pic32cm_mc00_curiosity_pro/peripheral/nvic/: plib_nvic.h plib_nvic.c
    ../src/config/pic32cm_mc00_curiosity_pro/peripheral/wdt/: plib_wdt.h plib_wdt.c
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm0plus.h mpu_armv7.h cachel1_armv7.h
    ../src/config/pic32cm_mc00_curiosity_pro/classb/: classb_result_management.h classb_cpu_reg_test.h classb.h classb_common.h classb_sram_test.h classb_sram_algorithm.h classb_flash_test.h classb_clock_test.h classb_interrupt_test.h classb_io_pin_test.h classb_result_management.S classb_cpu_reg_test.S classb.c classb_cpu_pc_test.c classb_sram_test.c classb_sram_algorithm.c classb_flash_test.c classb_clock_test.c classb_interrupt_test.c classb_io_pin_test.c
    ../src/: main.c
    ../src/config/pic32cm_mc00_curiosity_pro/stdio/: keil_monitor.c
